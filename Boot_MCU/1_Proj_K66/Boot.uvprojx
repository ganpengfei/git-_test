# Keil uVision project Boot.uvprojx, settings and files
target Boot (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MK66FN2M0xxx18 Freescale
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IROM(0x00000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Boot_K66 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MK66FN2M0VMD18, ARM_MATH_CM4
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186,66,111,223  --library_interface=armcc
  c include: ..\3_Src;..\4_Lib\K66\CMSIS\Include;..\4_Lib\K66\MK66F18\utilities;..\4_Lib\K66\MK66F18\drivers;..\4_Lib\K66\MK66F18\arm;..\4_Lib\K66\MK66F18;..\4_Lib\K66\MK66F18\middleware\dma_manager_2.0.0;.\OwnCode
  asm define: __CWCC__,__IAR_SYSTEMS_ICC__
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ..\5_Link\MK66FN2M0xxx18_flash.scf
  group Src/App
    ../3_Src/Main/: main.c
    ../3_Src/CtlBoot/: CtlBoot.c
    ../3_Src/CtlFpga/: CtlFpga.c
    ./OwnCode/: config.h
  group Src/Dev
    ../3_Src/DevAcu/: DevAcu.c
    ../3_Src/DrvDbg/: DevDbg.c
  group Src/Drv
    ../3_Src/DrvCan/: DrvCan.c
    ../3_Src/DrvUart/: DrvUart.c
    ../3_Src/DrvTimer/: DrvTimer.c
    ../3_Src/DrvDbg/: DrvDbg.c
    ../3_Src/DrvUpDate/: DrvUpDate.c
    ../3_Src/DrvFlash/: DrvFlash.c
    ./OwnCode/DrvCfg/: DrvCfg.c
  group Src/Inc
    ../3_Src/CtlBoot/: CtlBoot.h
    ../3_Src/CtlFpga/: CtlFpga.h
    ../3_Src/DevAcu/: DevAcu.h
    ../3_Src/DrvCan/: DrvCan.h
    ../3_Src/DrvDbg/: DrvDbg.h DevDbg.h
    ../3_Src/DrvFlash/: DrvFlash.h
    ../3_Src/DrvTimer/: DrvTimer.h
    ../3_Src/DrvUart/: DrvUart.h
    ../3_Src/DrvUpDate/: DrvUpDate.h
    ./OwnCode/: include.h
    ./OwnCode/DrvCfg/: DrvCfg.h
  group Lib
    ../4_Lib/K66/MK66F18/drivers/: fsl_clock.c fsl_common.c fsl_dmamux.c fsl_edma.c fsl_flash.c fsl_flexcan.c fsl_gpio.c fsl_tpm.c fsl_uart.c fsl_uart_edma.c fsl_pit.c
    ../4_Lib/K66/MK66F18/middleware/dma_manager_2.0.0/: fsl_dma_manager.c
  group Startup
    ../4_Lib/K66/MK66F18/: system_MK66F18.c system_MK66F18.h
    ../4_Lib/K66/MK66F18/arm/: startup_MK66F18.s
