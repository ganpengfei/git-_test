# Keil uVision project Boot.uvprojx, settings and files
target Boot (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MKS22FN256xxx12 NXP
  pack: Keil.Kinetis_KSxx_DFP.1.1.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x1FFFC000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Boot_K22 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: CPU_MKS22FN256VLL12, MAPS_KS22, TOWER,NODEBUG
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186,66,111,223  --library_interface=armcc
  c include: ..\3_Src;.\OwnCode;..\4_Lib\K22;..\4_Lib\K22\CMSIS\Include;..\4_Lib\K22\MKS22F12;..\4_Lib\K22\MKS22F12\drivers;..\4_Lib\K22\MKS22F12\utilities;..\4_Lib\K22\MKS22F12\dma_manager
  asm define: __CWCC__,__IAR_SYSTEMS_ICC__
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x10000
  scatter file: ..\4_Lib\K22\MKS22F12\linker\arm\MKS22FN256xxx12_flash.scf
  group Src/App
    ../3_Src/Main/: main.c
    ../3_Src/CtlBoot/: CtlBoot.c
    ../3_Src/CtlFpga/: CtlFpga.c
    ./OwnCode/: config.h
  group Src/Dev
    ../3_Src/DevAcu/: DevAcu.c
    ../3_Src/DrvDbg/: DevDbg.c
  group Src/Drv
    ../3_Src/DrvCan/: DrvCan.c
    ../3_Src/DrvUart/: DrvUart.c
    ../3_Src/DrvTimer/: DrvTimer.c
    ../3_Src/DrvDbg/: DrvDbg.c
    ../3_Src/DrvUpDate/: DrvUpDate.c
    ../3_Src/DrvFlash/: DrvFlash.c
    ./OwnCode/DrvCfg/: DrvCfg.c
  group Src/Inc
    ../3_Src/CtlBoot/: CtlBoot.h
    ../3_Src/CtlFpga/: CtlFpga.h
    ../3_Src/DevAcu/: DevAcu.h
    ../3_Src/DrvCan/: DrvCan.h
    ../3_Src/DrvDbg/: DrvDbg.h DevDbg.h
    ../3_Src/DrvTimer/: DrvTimer.h
    ../3_Src/DrvUart/: DrvUart.h
    ../3_Src/DrvUpDate/: DrvUpDate.h
    ./OwnCode/: include.h
    ./OwnCode/DrvCfg/: DrvCfg.h
    ../3_Src/DrvFlash/: DrvFlash.h
  group Lib
    ../4_Lib/K22/MKS22F12/: fsl_clock.c
    ../4_Lib/K22/MKS22F12/drivers/: fsl_adc16.c fsl_common.c fsl_crc.c fsl_dmamux.c fsl_edma.c fsl_flash.c fsl_flexcan.c fsl_gpio.c fsl_mcg.c fsl_pit.c fsl_smc.c fsl_tpm.c fsl_uart.c fsl_uart_edma.c
    ../4_Lib/K22/MKS22F12/dma_manager/: fsl_dma_manager.c
  group Startup
    ../4_Lib/K22/MKS22F12/: system_MKS22F12.c system_MKS22F12.h
    ../4_Lib/K22/MKS22F12/arm/: startup_MKS22F12.s
